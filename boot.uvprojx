# Keil uVision project boot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\LIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./LIB/: lpc177x_8x_uart.c lpc177x_8x_timer.c debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c
software components: CMSIS:CORE 5.6.0, Device:GPDMA 1.4.0, Device:PIN 1.1.0, Device:Startup 1.0.0
